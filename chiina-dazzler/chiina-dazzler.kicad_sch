File: chiina-dazzler/chiina-dazzler.kicad_sch (KiCad schematic)
At the start: 17 parts

Commit message: aaa
Other:
- moved on the sheet: C?, J?, R?, U?
